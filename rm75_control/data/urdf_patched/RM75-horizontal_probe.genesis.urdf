Commit message: 8.1修改前备份

File: rm75_control/data/urdf_patched/RM75-horizontal_probe.genesis.urdf (robot description, URDF)
Before this commit: robot RM75-6F-8dof-genesis, 13 links, 12 joints
Joints:
- joint rail_y: origin xyz=0 -0.4 0 rpy=0 0 0 -> xyz=0 0 0 rpy=0 0 0
